## boards/shields/two_percent_milk/Kconfig.defconfig
```kconfig
if TWO_PERCENT_MILK

config ZMK_KEYBOARD_NAME
  default "two_percent_milk"

endif
```
